# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

SUMMARY = "A simple CLI tool for ensuring that a given node script runs continuously (i.e. forever)"
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# The following license files were not able to be identified and are
# represented as "Unknown" below, you will need to check them yourself:
#   node_modules/balanced-match/LICENSE.md
#   node_modules/clone/LICENSE
#   node_modules/process-nextick-args/license.md
#   node_modules/nan/LICENSE.md
#   node_modules/atob/LICENSE
#   node_modules/atob/LICENSE.DOCS
#   node_modules/colors/MIT-LICENSE.txt
#   node_modules/source-map/LICENSE
#   node_modules/fsevents/LICENSE
#   node_modules/upath/LICENSE
#   node_modules/through/LICENSE.APACHE2
#   node_modules/readable-stream/LICENSE
#   node_modules/isstream/LICENSE.md
#   node_modules/revalidator/LICENSE
#   node_modules/cliff/node_modules/colors/MIT-LICENSE.txt
#   node_modules/fs.realpath/LICENSE
#   node_modules/prettyjson/node_modules/colors/LICENSE
#   node_modules/string_decoder/LICENSE
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.
LICENSE = "MIT & ISC & Unknown"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=da5360871cfc7e3df08cde6a2adeac25 \
                    file://node_modules/regexp.prototype.flags/LICENSE;md5=de214a0e2991ba4bb802f96348cbb1ce \
                    file://node_modules/number-is-nan/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/is-binary-path/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/assign-symbols/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/source-map-resolve/LICENSE;md5=c71a7496543458e1dd6bf60d8224c813 \
                    file://node_modules/binary-extensions/license;md5=915042b5df33c31a6db2b37eadaa00e3 \
                    file://node_modules/caller/LICENSE;md5=0928c6d4d0c0cd10ae7a780b8d22e6bf \
                    file://node_modules/shush/LICENSE;md5=0928c6d4d0c0cd10ae7a780b8d22e6bf \
                    file://node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/nanomatch/LICENSE;md5=01a8b0026a66c0139b0434fba078fa92 \
                    file://node_modules/micromatch/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
                    file://node_modules/repeat-element/LICENSE;md5=b561e0a423bedc9d9ca9c8c67d40abb9 \
                    file://node_modules/path-dirname/license;md5=83e325e26e7a045eef3df8d1082df8c0 \
                    file://node_modules/anymatch/LICENSE;md5=c76a3b016e50ccf2ee29ed359fb84df1 \
                    file://node_modules/anymatch/node_modules/normalize-path/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/object-copy/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/object-copy/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/object-copy/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/glob-parent/LICENSE;md5=429b0fedc27562e9e8deba9a9585396d \
                    file://node_modules/glob-parent/node_modules/is-glob/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/base/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/base/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/base/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/base/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/base/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/eyes/LICENSE;md5=f3d830b792e909506145eb84ff52da91 \
                    file://node_modules/file-uri-to-path/LICENSE;md5=9513dc0b97137379cfabc81b60889174 \
                    file://node_modules/balanced-match/LICENSE.md;md5=7fa99ddc3424107350ca6e9a24552085 \
                    file://node_modules/clone/LICENSE;md5=411e33109fa516d190d232100fdc7f8e \
                    file://node_modules/read/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/is-glob/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/has-value/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/nconf/LICENSE;md5=1d298eab46fa1a8d29896cf1370ec6f9 \
                    file://node_modules/nconf/node_modules/async/LICENSE;md5=dc113e0fc4029c29942399ad22425402 \
                    file://node_modules/object-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/event-stream/LICENCE;md5=84ddd974e10adfabbf232e7efb7ed715 \
                    file://node_modules/event-stream/node_modules/optimist/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/is-number/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/is-number/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/nssocket/LICENSE;md5=159a36f4e71505b13c38f1d81591426e \
                    file://node_modules/string.prototype.trimright/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/unset-value/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/unset-value/node_modules/has-value/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/unset-value/node_modules/has-value/node_modules/isobject/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/unset-value/node_modules/has-values/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/object-inspect/LICENSE;md5=288162f1d1bfa064f127f2b42d2a656f \
                    file://node_modules/util-deprecate/LICENSE;md5=b7c99ef4b0f3ad9911a52219947f8cf0 \
                    file://node_modules/extglob/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/extglob/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/extglob/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/extglob/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/extglob/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/extglob/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/snapdragon-node/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/snapdragon-node/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/snapdragon-node/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/snapdragon-node/node_modules/define-property/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/snapdragon-node/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/object.pick/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/camelcase/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/resolve-url/LICENSE;md5=7e0155ddd0674c6065b91c9a5a15798d \
                    file://node_modules/minimatch/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/process-nextick-args/license.md;md5=216769dac98a78ec088ee7cc6fad1dfa \
                    file://node_modules/is-data-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/is-data-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/mkdirp/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/mkdirp/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/defined/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/arr-diff/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/readdirp/LICENSE;md5=66fbeb4568f5758ca9d4635c936da133 \
                    file://node_modules/flatiron/LICENSE;md5=dc5385a0e48bd49ac891b68f3e445ee7 \
                    file://node_modules/flatiron/node_modules/optimist/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/array-unique/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/string.prototype.trimleft/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/regex-not/LICENSE;md5=6c5e341361a86b6253a8e81978cbb67e \
                    file://node_modules/get-value/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/snapdragon/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/snapdragon/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/snapdragon/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/inflight/LICENSE;md5=90a3ca01a5efed8b813a81c6c8fa2e63 \
                    file://node_modules/concat-map/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/ansi-regex/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/i/LICENSE;md5=3fced11d6df719b47505837a51c16ae5 \
                    file://node_modules/object.assign/LICENSE;md5=2b439ca9e99134dee172a7cc6d989174 \
                    file://node_modules/rimraf/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/expand-brackets/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/expand-brackets/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/expand-brackets/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/remove-trailing-separator/license;md5=294c1c7712f9be26cef730b5ad95a6a5 \
                    file://node_modules/deep-equal/LICENSE;md5=ec4e94fe7abda03e2e44a713b0908a07 \
                    file://node_modules/pkginfo/LICENSE;md5=c018b0f606e174a199be171b05c4b77d \
                    file://node_modules/split-string/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/once/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/set-value/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/set-value/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/fragment-cache/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/has/LICENSE-MIT;md5=d000afc3c9ff3501a5610197db76a246 \
                    file://node_modules/static-extend/LICENSE;md5=d4f36f2681729e3ad311515c316b42ff \
                    file://node_modules/static-extend/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/wrappy/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/utile/LICENSE;md5=d039b65285c600ffe1775335e8fcdb20 \
                    file://node_modules/utile/node_modules/deep-equal/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/utile/node_modules/async/LICENSE;md5=dc113e0fc4029c29942399ad22425402 \
                    file://node_modules/utile/node_modules/ncp/LICENSE.md;md5=9bf7541c2b42385117669c2b9ba8673a \
                    file://node_modules/decamelize/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/y18n/LICENSE;md5=55e5f88040679148136545002139a8b1 \
                    file://node_modules/is-regex/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
                    file://node_modules/nan/LICENSE.md;md5=e6270b7774528599f2623a4aeb625829 \
                    file://node_modules/for-in/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/atob/LICENSE;md5=493adefc1fe80b079a23203e4732d945 \
                    file://node_modules/atob/LICENSE.DOCS;md5=980f12f548ed1abbfc4771f40a8116d3 \
                    file://node_modules/yargs/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/wrap-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/is-date-object/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/is-descriptor/node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/broadway/LICENSE;md5=dc5385a0e48bd49ac891b68f3e445ee7 \
                    file://node_modules/broadway/node_modules/nconf/LICENSE;md5=dc5385a0e48bd49ac891b68f3e445ee7 \
                    file://node_modules/broadway/node_modules/nconf/node_modules/async/LICENSE;md5=64a378b2b01424fe22d54bc626175994 \
                    file://node_modules/broadway/node_modules/utile/LICENSE;md5=ebfbec53701ae21e11c903b288b9d352 \
                    file://node_modules/broadway/node_modules/utile/node_modules/async/LICENSE;md5=64a378b2b01424fe22d54bc626175994 \
                    file://node_modules/broadway/node_modules/winston/LICENSE;md5=124783bb03d1b801c23d11f07b62be0a \
                    file://node_modules/broadway/node_modules/winston/node_modules/async/LICENSE;md5=64a378b2b01424fe22d54bc626175994 \
                    file://node_modules/broadway/node_modules/cliff/LICENSE;md5=ebfbec53701ae21e11c903b288b9d352 \
                    file://node_modules/broadway/node_modules/optimist/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/is-extendable/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/snapdragon-util/LICENSE;md5=168f94bc7d2150e77c0dfd129126cd85 \
                    file://node_modules/snapdragon-util/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/posix-character-classes/LICENSE;md5=525d8ba712c1da523da9e6e7d61ff440 \
                    file://node_modules/colors/MIT-LICENSE.txt;md5=a4ae3515249a7180a4af2a7be17636d9 \
                    file://node_modules/is-fullwidth-code-point/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/stack-trace/License;md5=9fbf93f7a763e64c0a30207b5693bf75 \
                    file://node_modules/define-property/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/define-property/node_modules/is-data-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/define-property/node_modules/is-descriptor/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/define-property/node_modules/is-accessor-descriptor/LICENSE;md5=1027d1336ffdd3b96ff1cfd1d3bea3fc \
                    file://node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/brace-expansion/LICENSE;md5=a5df515ef062cc3affd8c0ae59c059ec \
                    file://node_modules/has-values/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/has-values/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/core-util-is/LICENSE;md5=6126e36127d20ec0e2f637204a5c68ff \
                    file://node_modules/resumer/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/object-keys/LICENSE;md5=0026e638d7d5c5f2768864ce0074f8ad \
                    file://node_modules/union-value/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/mixin-deep/LICENSE;md5=4e0921625c33cf4e6990a6416848a6e5 \
                    file://node_modules/mixin-deep/node_modules/is-extendable/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/os-locale/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/lcid/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/is-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/arr-union/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/es-to-primitive/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/source-map/LICENSE;md5=b1ca6dbc0075d56cbd9931a75566cd44 \
                    file://node_modules/es-abstract/LICENSE;md5=53ffc646fdb83e45279cfe7105e5157b \
                    file://node_modules/safe-regex/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/is-callable/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/is-symbol/LICENSE;md5=5db8fa3e421a3211e6a3dc68544da455 \
                    file://node_modules/strip-ansi/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/fsevents/LICENSE;md5=9381eb0813adb052a6ce222b19dc9937 \
                    file://node_modules/isobject/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/window-size/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/define-properties/LICENSE;md5=53ffc646fdb83e45279cfe7105e5157b \
                    file://node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/decode-uri-component/license;md5=775415f59d9642dd552fd60e4c0adda4 \
                    file://node_modules/upath/LICENSE;md5=471875b18e742c52290b3f7ec4aa0b85 \
                    file://node_modules/wordwrap/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/tape/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/is-arguments/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
                    file://node_modules/to-regex-range/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/map-visit/LICENSE;md5=f6db0829782d67e30695686ebb45970a \
                    file://node_modules/arr-flatten/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/normalize-path/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
                    file://node_modules/through/LICENSE.APACHE2;md5=ffcf739dca268cb0f20336d6c1a038f1 \
                    file://node_modules/through/LICENSE.MIT;md5=e0f70a42adf526e6f5e605a94d98a420 \
                    file://node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/ini/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/cache-base/LICENSE;md5=2f5638b0557426da0c3bd67e00a0ebde \
                    file://node_modules/winston/LICENSE;md5=124783bb03d1b801c23d11f07b62be0a \
                    file://node_modules/winston/node_modules/async/LICENSE;md5=64a378b2b01424fe22d54bc626175994 \
                    file://node_modules/braces/LICENSE;md5=ccdc0959f67943eb090f7e7c299621af \
                    file://node_modules/braces/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/readable-stream/LICENSE;md5=a67a7926e54316d90c14f74f71080977 \
                    file://node_modules/isstream/LICENSE.md;md5=1798150b9d70250c42b55b3530e6af2b \
                    file://node_modules/revalidator/LICENSE;md5=9a6dc855e34c866b8210106221fced6b \
                    file://node_modules/cliff/LICENSE;md5=530d81982e1bf74ea578e7dd9c30ff6b \
                    file://node_modules/cliff/node_modules/colors/MIT-LICENSE.txt;md5=5bc6c72caa0dcc082d24a52a6ae12112 \
                    file://node_modules/forever-monitor/LICENSE;md5=da5360871cfc7e3df08cde6a2adeac25 \
                    file://node_modules/cliui/LICENSE.txt;md5=83623193d3051ca8068a89a455c699ca \
                    file://node_modules/optimist/LICENSE;md5=b2d989bc186e7f6b418a5fdd5cc0b56b \
                    file://node_modules/has-symbols/LICENSE;md5=afee57a289508ed4df3456667778aaf6 \
                    file://node_modules/function-bind/LICENSE;md5=e7417c1a8ad83f88bcac21ad440d48b2 \
                    file://node_modules/mute-stream/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/string-width/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/map-cache/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/collection-visit/LICENSE;md5=7159ba8f2e9f17d4c29d1a73c4f4b759 \
                    file://node_modules/is-extglob/LICENSE;md5=97b255bb4707da164bfaf4e5c7b9f9ef \
                    file://node_modules/director/LICENSE;md5=d09149fc1e5e5a1755e2523a9ca2253c \
                    file://node_modules/repeat-string/LICENSE;md5=fad3c8b9c04b365012f3d6821f2dda61 \
                    file://node_modules/glob/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/glob/node_modules/path-is-absolute/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/kind-of/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/fs.realpath/LICENSE;md5=062470525c8e380f8567f665ef554d11 \
                    file://node_modules/async/LICENSE;md5=dc113e0fc4029c29942399ad22425402 \
                    file://node_modules/is-windows/LICENSE;md5=5fb5a7fdbcfa3640822ec69bd3ee86e7 \
                    file://node_modules/use/LICENSE;md5=b561e0a423bedc9d9ca9c8c67d40abb9 \
                    file://node_modules/class-utils/LICENSE;md5=ffc896391717b946ebe09615926637e1 \
                    file://node_modules/class-utils/node_modules/define-property/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/copy-descriptor/LICENSE;md5=8a4b0e5fd41b2cf9072913a284384998 \
                    file://node_modules/ret/LICENSE;md5=9aeada1cccf95163778a1c8189c8f297 \
                    file://node_modules/extend-shallow/LICENSE;md5=4e0921625c33cf4e6990a6416848a6e5 \
                    file://node_modules/extend-shallow/node_modules/is-extendable/LICENSE;md5=78c705080a639d3bb4085a9d1bb22987 \
                    file://node_modules/urix/LICENSE;md5=7e0155ddd0674c6065b91c9a5a15798d \
                    file://node_modules/fill-range/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/fill-range/node_modules/extend-shallow/LICENSE;md5=360e60c9b7aa16428ee600ff20935e1f \
                    file://node_modules/is-accessor-descriptor/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/is-accessor-descriptor/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/to-regex/LICENSE;md5=01a8b0026a66c0139b0434fba078fa92 \
                    file://node_modules/is-plain-object/LICENSE;md5=3d83ea4c8ec9b31d9ff2c82fa29beabb \
                    file://node_modules/prettyjson/LICENSE;md5=bf3405c0c1adf75fa59dccf0b511a5cb \
                    file://node_modules/prettyjson/node_modules/colors/LICENSE;md5=441ee46669f9365ff2492e9b555c8ee7 \
                    file://node_modules/prettyjson/node_modules/minimist/LICENSE;md5=aea1cde69645f4b99be4ff7ca9abcce1 \
                    file://node_modules/to-object-path/LICENSE;md5=a0bd3ad96ad6f399ce73b75ce8332105 \
                    file://node_modules/to-object-path/node_modules/kind-of/LICENSE;md5=c8f80ed52c9074414e8a69541cdc1587 \
                    file://node_modules/prompt/LICENSE;md5=ebfbec53701ae21e11c903b288b9d352 \
                    file://node_modules/prompt/node_modules/utile/LICENSE;md5=ebfbec53701ae21e11c903b288b9d352 \
                    file://node_modules/prompt/node_modules/utile/node_modules/async/LICENSE;md5=64a378b2b01424fe22d54bc626175994 \
                    file://node_modules/code-point-at/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/object-is/LICENSE;md5=d22b3eb619d81197fd4f3ca47c2c1ea5 \
                    file://node_modules/object-is/node_modules/es-abstract/LICENSE;md5=53ffc646fdb83e45279cfe7105e5157b \
                    file://node_modules/pascalcase/LICENSE;md5=e060235353cb686ae1695ec7db63cfbc \
                    file://node_modules/graceful-fs/LICENSE;md5=fd63805fd8e3797063b247781e5ee6e4 \
                    file://node_modules/string_decoder/LICENSE;md5=14af51f8c0a6c6e400b53e18c6e5f85c \
                    file://node_modules/ncp/LICENSE.md;md5=9bf7541c2b42385117669c2b9ba8673a \
                    file://node_modules/source-map-url/LICENSE;md5=c5fd933c72ea96892cc6dcdcdd6c766f \
                    file://node_modules/bindings/LICENSE.md;md5=471723f32516f18ef36e7ef63580e4a8 \
                    file://package.json;md5=2095b77fa53cba054e0863f0188aab88 \
                    file://node_modules/ansi-regex/package.json;md5=fbd3a8909a47de214c7288046091267c \
                    file://node_modules/anymatch/node_modules/normalize-path/package.json;md5=afe1b46cc945abf437cdbe3c9a9929e8 \
                    file://node_modules/anymatch/package.json;md5=f213b891665d8a8e4b022b8e306f6e80 \
                    file://node_modules/arr-diff/package.json;md5=5ac535a60cd9b72b89f97eac2044c950 \
                    file://node_modules/arr-flatten/package.json;md5=7f21caea60a39f18e0d6f05d54396c11 \
                    file://node_modules/arr-union/package.json;md5=e30278a1b01880e0835afd3de59cf12d \
                    file://node_modules/array-unique/package.json;md5=8c59b5beb7fa949cd47ade511f823214 \
                    file://node_modules/assign-symbols/package.json;md5=f2fbb1be41769bcec4582073a3db8c8d \
                    file://node_modules/async/package.json;md5=c307f401b8512aa5ab70eb7ac1efe62d \
                    file://node_modules/async-each/package.json;md5=8ecad6782172821cdbd2b68a5635eeb4 \
                    file://node_modules/atob/package.json;md5=cad00c76eb03ce16bc9ca3a2e0ee982e \
                    file://node_modules/balanced-match/package.json;md5=a2181cb8cab70df2084e1bdce79a389b \
                    file://node_modules/base/node_modules/define-property/package.json;md5=2afc9d66b46a8a1a06743d6004c27ecb \
                    file://node_modules/base/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/base/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/base/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/base/package.json;md5=4b68e486bb2271317f7373ffac92395d \
                    file://node_modules/binary-extensions/package.json;md5=b69a1700220ecc757f5595c55c0332af \
                    file://node_modules/bindings/package.json;md5=17005447df8440e0e386849b8fa2b682 \
                    file://node_modules/brace-expansion/package.json;md5=effd91994b1b7ddb8a33060ad4541e6a \
                    file://node_modules/braces/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/braces/package.json;md5=0956bb2b39c31ba39e7951b3c4c131c2 \
                    file://node_modules/broadway/node_modules/cliff/package.json;md5=4d5631483e218f9a52d0dc12fb294d2a \
                    file://node_modules/broadway/node_modules/eventemitter2/package.json;md5=52535f01eb9b9c338e0d6e2a1ecd72f4 \
                    file://node_modules/broadway/node_modules/nconf/node_modules/async/package.json;md5=eae59bcc1a34df541efb423cee0653d1 \
                    file://node_modules/broadway/node_modules/nconf/package.json;md5=8596547091d9665752f4965c07a3389a \
                    file://node_modules/broadway/node_modules/optimist/package.json;md5=e35c5f4ac8770f17ad3c3310a5980b20 \
                    file://node_modules/broadway/node_modules/utile/node_modules/async/package.json;md5=b9af078ffbadf94f89007b64419058ef \
                    file://node_modules/broadway/node_modules/utile/package.json;md5=1568d3bc2fe643977a0fd468f5a0af42 \
                    file://node_modules/broadway/node_modules/winston/node_modules/async/package.json;md5=b9af078ffbadf94f89007b64419058ef \
                    file://node_modules/broadway/node_modules/winston/package.json;md5=00008f62168c1b88f2ac59864bcaf5df \
                    file://node_modules/broadway/package.json;md5=c62d6a600fe8cc7e3ad4ce9425a81d8c \
                    file://node_modules/cache-base/package.json;md5=f0150262ed8266c8c5c927b9de4d31b0 \
                    file://node_modules/caller/package.json;md5=c8605d56538609005beb4a660b2cd3d1 \
                    file://node_modules/camelcase/package.json;md5=dea8d66e97c13f69e0be80d37ae2c4b9 \
                    file://node_modules/chokidar/package.json;md5=da32260696104ee51bdf59f466f37cbd \
                    file://node_modules/class-utils/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/class-utils/package.json;md5=0de6151f3fbfd13c0a12004e8e754003 \
                    file://node_modules/cliff/node_modules/colors/package.json;md5=00a1f898fdf004f2b03434568bcec779 \
                    file://node_modules/cliff/package.json;md5=fa05548cb26391df2714cc3aef82e9e3 \
                    file://node_modules/cliui/package.json;md5=7aec291df2580420b1543c382213e023 \
                    file://node_modules/clone/package.json;md5=98d2bb9360cfe43fa3f3a9ac0d35b317 \
                    file://node_modules/code-point-at/package.json;md5=4e85e8a583ebac72e2065d9e576c92cf \
                    file://node_modules/collection-visit/package.json;md5=9cf59dca6759b69fe52c37f98b894962 \
                    file://node_modules/colors/package.json;md5=3de43238276a9d0a704ef0791759e294 \
                    file://node_modules/component-emitter/package.json;md5=81dd6df22a2628fa27a5c4937df567f6 \
                    file://node_modules/concat-map/package.json;md5=85d8a674998927862b17adef4aa6a7b1 \
                    file://node_modules/copy-descriptor/package.json;md5=ecd13fcc72056398f309b3be5c9e623c \
                    file://node_modules/core-util-is/package.json;md5=685b947d7cae341b1e6f305b205da7ae \
                    file://node_modules/cycle/package.json;md5=5a4ef3aea1847dea1fe1fab134f36680 \
                    file://node_modules/debug/package.json;md5=71a7656944ffe50cc27ebe02491ae49b \
                    file://node_modules/decamelize/package.json;md5=494b4faeb16e12979e988b49de7684d6 \
                    file://node_modules/decode-uri-component/package.json;md5=3c2da9242641c103907dee7ee36c36d9 \
                    file://node_modules/deep-equal/package.json;md5=508c75255e391edb53f12a8abbef6ef0 \
                    file://node_modules/define-properties/package.json;md5=78d159123901bac44c44e358eb28f652 \
                    file://node_modules/define-property/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/define-property/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/define-property/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/define-property/package.json;md5=29d59fea60bc8344de21b01b76768dbf \
                    file://node_modules/defined/package.json;md5=262e00275f8e3ffa289d3419aaffd23e \
                    file://node_modules/director/package.json;md5=157993724e5de3eadde75f4be3faafff \
                    file://node_modules/es-abstract/package.json;md5=709c01cc649596617f335279fac6a3fd \
                    file://node_modules/es-to-primitive/package.json;md5=b183238ced55e20cc222932f965376a2 \
                    file://node_modules/event-stream/node_modules/optimist/package.json;md5=79f1060562fd246b45060edff256ae72 \
                    file://node_modules/event-stream/package.json;md5=c4f48476450be4917a42fb1456977ee6 \
                    file://node_modules/expand-brackets/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/expand-brackets/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/expand-brackets/package.json;md5=117ad2f3da10271826c98537b0b7d62d \
                    file://node_modules/extend-shallow/node_modules/is-extendable/package.json;md5=b569f78b3ad4a0c87d7e00873edab7da \
                    file://node_modules/extend-shallow/package.json;md5=c41732fba62098ae649aec68c78c7d01 \
                    file://node_modules/extglob/node_modules/define-property/package.json;md5=2afc9d66b46a8a1a06743d6004c27ecb \
                    file://node_modules/extglob/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/extglob/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/extglob/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/extglob/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/extglob/package.json;md5=d4f33fd0f4970db7bbc9a74b6c1ef530 \
                    file://node_modules/eyes/package.json;md5=0eb1c01d8a8b486dea8843b8c6e2b4bb \
                    file://node_modules/file-uri-to-path/package.json;md5=65f30030f0e7b2eff552eaabd8bb1fe1 \
                    file://node_modules/fill-range/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/fill-range/package.json;md5=663440166ce71901e0df47549bb99966 \
                    file://node_modules/flatiron/node_modules/optimist/package.json;md5=e35c5f4ac8770f17ad3c3310a5980b20 \
                    file://node_modules/flatiron/package.json;md5=07514db04403525e1f9f6fb3d4ecb150 \
                    file://node_modules/for-in/package.json;md5=68d1bcc83288065fe21285a685c389c3 \
                    file://node_modules/forever-monitor/package.json;md5=9c2fccca5bb794d50a919f24076767dd \
                    file://node_modules/fragment-cache/package.json;md5=90f40e0f75baceab0c48be8cc4a897a4 \
                    file://node_modules/fs.realpath/package.json;md5=3aa3d67ce378e330e293496dd3b9a506 \
                    file://node_modules/fsevents/package.json;md5=038b1599cd8557067d988ae12c1ee34c \
                    file://node_modules/function-bind/package.json;md5=f453e26c8d3482b4c3736f53303b4ec5 \
                    file://node_modules/get-value/package.json;md5=987510f1e53242ffe9851555ab3350a5 \
                    file://node_modules/glob/node_modules/path-is-absolute/package.json;md5=ef6e018bdf67b82ab1285bc799b5367b \
                    file://node_modules/glob/package.json;md5=72f1c5e5afe4941e1e07944aa1a57f4f \
                    file://node_modules/glob-parent/node_modules/is-glob/package.json;md5=71cd690e8d61d506b7386ca44e6a4405 \
                    file://node_modules/glob-parent/package.json;md5=04bf0952f710c774bd9c759b11998416 \
                    file://node_modules/graceful-fs/package.json;md5=b31cf400f270df9d7173307ac050e826 \
                    file://node_modules/has/package.json;md5=2fee243336ba5aeebed1e0145472cd49 \
                    file://node_modules/has-symbols/package.json;md5=24e9d883e10a6e4a622fcf6357ee5383 \
                    file://node_modules/has-value/package.json;md5=73de914f6546bc1c23de28d2ca03126e \
                    file://node_modules/has-values/node_modules/kind-of/package.json;md5=c80e6332d2836d915077531c8d1d72df \
                    file://node_modules/has-values/package.json;md5=3e492c1f66ae74b8e1fb0cf1f0be81e2 \
                    file://node_modules/i/package.json;md5=6a1f2ed173442a4ec8e99d6930b7a32a \
                    file://node_modules/inflight/package.json;md5=85ba25624378c23e1ee9b33d3d103bf0 \
                    file://node_modules/inherits/package.json;md5=74b2e77f5c27cdb14784f7f2512a1918 \
                    file://node_modules/ini/package.json;md5=c817b5b8913b3ab535d215aad84c3a7f \
                    file://node_modules/invert-kv/package.json;md5=d22fce2d11b00103e7c04568240f9ac4 \
                    file://node_modules/is-accessor-descriptor/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/is-accessor-descriptor/package.json;md5=251b51bed1be5461844300dffb7156b0 \
                    file://node_modules/is-arguments/package.json;md5=ef233192ba7280452977c9c6ab37e39c \
                    file://node_modules/is-binary-path/package.json;md5=adc2f2d0c211f56398e31d32c92b1b6e \
                    file://node_modules/is-buffer/package.json;md5=b5faa5fac071732491a62f6168f3bae6 \
                    file://node_modules/is-callable/package.json;md5=0c22febfbddefa14c4ce2059d2b53525 \
                    file://node_modules/is-data-descriptor/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/is-data-descriptor/package.json;md5=7e85bd6728bd7ee0297e85d1ecc173d7 \
                    file://node_modules/is-date-object/package.json;md5=b0366c20b2ee192e8155131e25328520 \
                    file://node_modules/is-descriptor/node_modules/kind-of/package.json;md5=9c5fbbf74e4f49e6fc0dcd82ca1c7686 \
                    file://node_modules/is-descriptor/package.json;md5=5990d4cad3ecf89ee1864dcf10fc60cb \
                    file://node_modules/is-extendable/package.json;md5=0c2e213489eae83b656348e97ff8bbe8 \
                    file://node_modules/is-extglob/package.json;md5=90ad861bbbc1f6ee662d11dd78cdc2fd \
                    file://node_modules/is-fullwidth-code-point/package.json;md5=6bd5a684a5081f2d099cb800cf53ebd6 \
                    file://node_modules/is-glob/package.json;md5=5a2dd66f0b38d803cd44e2547e800166 \
                    file://node_modules/is-number/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/is-number/package.json;md5=34f310b6d2cfde34f4f0db50ad254851 \
                    file://node_modules/is-plain-object/package.json;md5=9d4258679c223aa77b7db3d91796ce6f \
                    file://node_modules/is-regex/package.json;md5=185e07e8dd984ea884274f66139787f1 \
                    file://node_modules/is-symbol/package.json;md5=cf109cd5c94e334929842882585e5cb6 \
                    file://node_modules/is-windows/package.json;md5=5a2ed52f501e3a4a772b50bf34c752eb \
                    file://node_modules/isarray/package.json;md5=a490f11007b2cc9d19c4a250592c2e71 \
                    file://node_modules/isobject/package.json;md5=6f27623b2c39dde8a528a8446e4f2cc1 \
                    file://node_modules/isstream/package.json;md5=2c74d78c5b8e181e78e90b9a3e2fd0e0 \
                    file://node_modules/jsonify/package.json;md5=4d6afd81aded57a3818e2bc4327c8868 \
                    file://node_modules/kind-of/package.json;md5=0eadbbda9b0d0f582c6bc804ff959e63 \
                    file://node_modules/lazy/package.json;md5=60051d9162ce2b2777cbdd4f76ac44ef \
                    file://node_modules/lcid/package.json;md5=f1f2999e9ced8e9a58ebe90497c9f1ee \
                    file://node_modules/map-cache/package.json;md5=acd7503821d165d4848314e17c612ce1 \
                    file://node_modules/map-visit/package.json;md5=8fbba381ef7e234051cc98e7f7251ca3 \
                    file://node_modules/micromatch/package.json;md5=b9cec2ad4947c01f579f8248fcd3d359 \
                    file://node_modules/minimatch/package.json;md5=b763d93b18d070a6449399d2e92d8c32 \
                    file://node_modules/minimist/package.json;md5=5cdc9b4d6017e4086edb5a4f8443b0be \
                    file://node_modules/mixin-deep/node_modules/is-extendable/package.json;md5=b569f78b3ad4a0c87d7e00873edab7da \
                    file://node_modules/mixin-deep/package.json;md5=897a790e3d3372fd83dcd67f35749d55 \
                    file://node_modules/mkdirp/node_modules/minimist/package.json;md5=84505571ecc56b8071068f44de7c79b2 \
                    file://node_modules/mkdirp/package.json;md5=3b5ba3c4a04a8b0520bd0d392cf1c48f \
                    file://node_modules/ms/package.json;md5=cbd55880a650b56c3d5acddbbdbee9bc \
                    file://node_modules/mute-stream/package.json;md5=f0b94d5a5b779036f9166f972adfe48b \
                    file://node_modules/nan/package.json;md5=0d84def6cc44f9f7554b911d010a75da \
                    file://node_modules/nanomatch/package.json;md5=6aaee43183e8a7c47d2b610952bb870f \
                    file://node_modules/nconf/node_modules/async/package.json;md5=c307f401b8512aa5ab70eb7ac1efe62d \
                    file://node_modules/nconf/package.json;md5=cb23f35808da6d523e0bcfbe76237490 \
                    file://node_modules/ncp/package.json;md5=7fcfc0da33d97530836957ff7dcb0de8 \
                    file://node_modules/normalize-path/package.json;md5=8a437fdddf8bae5cce39556e3f830975 \
                    file://node_modules/nssocket/node_modules/eventemitter2/package.json;md5=52535f01eb9b9c338e0d6e2a1ecd72f4 \
                    file://node_modules/nssocket/package.json;md5=bd6c2e1e829d914f36aeb1da7179de7d \
                    file://node_modules/number-is-nan/package.json;md5=2b5b5a279c98be57ebafdaa605a14584 \
                    file://node_modules/object-assign/package.json;md5=2854c33ba575a9ebc613d1a617ece277 \
                    file://node_modules/object-copy/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/object-copy/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/object-copy/package.json;md5=89b7b1d90d56bb98ef517f52801cf1b6 \
                    file://node_modules/object-inspect/package.json;md5=e81127a7cbe105306fb4fb119852780d \
                    file://node_modules/object-is/node_modules/es-abstract/package.json;md5=01354670387635fadc398fa5e12a03c6 \
                    file://node_modules/object-is/package.json;md5=ac83a37524138179c1d873ec0269b32b \
                    file://node_modules/object-keys/package.json;md5=f008c51545b8133eebae07e2046d241f \
                    file://node_modules/object-visit/package.json;md5=abd0bdc0f3cfea9705a82e9bc14038d3 \
                    file://node_modules/object.assign/package.json;md5=5e2951a866b44b080fb677a1c26c799b \
                    file://node_modules/object.pick/package.json;md5=f4387ea465f917e297581815a19748aa \
                    file://node_modules/once/package.json;md5=afb6ea3bdcad6397e11a71615bd06e3b \
                    file://node_modules/optimist/package.json;md5=271658d42746bc19e9c553da871d4a8e \
                    file://node_modules/os-locale/package.json;md5=e7a6514c532cfd826d59fbf0cfe8938e \
                    file://node_modules/pascalcase/package.json;md5=933964e8e6b0c51fe219f7ea58002d18 \
                    file://node_modules/path-dirname/package.json;md5=e9b8273ed2f66600f0a2f59e44bc6d1f \
                    file://node_modules/path-is-absolute/package.json;md5=ef6e018bdf67b82ab1285bc799b5367b \
                    file://node_modules/pkginfo/package.json;md5=32273dce761addad51e944e4701ff9e9 \
                    file://node_modules/posix-character-classes/package.json;md5=90be4a75261123c121d1bd26a300da0e \
                    file://node_modules/prettyjson/node_modules/colors/package.json;md5=785e9848cab7317e2e17febc1d9b4f75 \
                    file://node_modules/prettyjson/node_modules/minimist/package.json;md5=7e2e3dffb617fdd574e0b58744bb9da5 \
                    file://node_modules/prettyjson/package.json;md5=d22086d089c20489635764895856872e \
                    file://node_modules/process-nextick-args/package.json;md5=6bd1fff965ff97b4aff54e6b4e382ed0 \
                    file://node_modules/prompt/node_modules/utile/node_modules/async/package.json;md5=b9af078ffbadf94f89007b64419058ef \
                    file://node_modules/prompt/node_modules/utile/package.json;md5=1568d3bc2fe643977a0fd468f5a0af42 \
                    file://node_modules/prompt/package.json;md5=d6379a530774d6a776128b2b64120a0f \
                    file://node_modules/ps-tree/package.json;md5=822587d11eef28bb7a59322827363bdf \
                    file://node_modules/read/package.json;md5=3cede436c9bfcfec87f4d83347a0cae0 \
                    file://node_modules/readable-stream/package.json;md5=55d646ab9e50735393b18c874d0bd5ab \
                    file://node_modules/readdirp/package.json;md5=265d90c60267cbde402a025a62dbfe01 \
                    file://node_modules/regex-not/package.json;md5=ef993e8d2313a18591d9fc36bfe1635d \
                    file://node_modules/regexp.prototype.flags/package.json;md5=288e33b5e607e05b778b31c59e05dd2e \
                    file://node_modules/remove-trailing-separator/package.json;md5=ba6eed8cddd45e58dfc64c382f54e24e \
                    file://node_modules/repeat-element/package.json;md5=bfba170ea7d20c1d85f4bf34582fcdae \
                    file://node_modules/repeat-string/package.json;md5=bc161704e452cf4ab0e6d92a3f93881c \
                    file://node_modules/resolve-url/package.json;md5=9bdafeb86a13dd230ba11d4666fb83bc \
                    file://node_modules/resumer/package.json;md5=276766544e21fe2a2f0f6e31b44f3b13 \
                    file://node_modules/ret/package.json;md5=873a515c64ff7e8be55f58d339eb65e4 \
                    file://node_modules/revalidator/package.json;md5=985e9848a3673fab63f9d644717d2935 \
                    file://node_modules/rimraf/package.json;md5=780e9fe0add5d2e91b79bf0f42d116ae \
                    file://node_modules/safe-buffer/package.json;md5=bd7ef6f38f0ba20882d2601bd3ecaf11 \
                    file://node_modules/safe-regex/package.json;md5=2d61123b0dab764e2d02612602ebc8d3 \
                    file://node_modules/secure-keys/package.json;md5=b565059137bec8952c20f609ac5b94bf \
                    file://node_modules/set-value/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/set-value/package.json;md5=71dd072568acbcd8f492a8d90483126e \
                    file://node_modules/shush/package.json;md5=d25046ccbc20386fa7386f80f97b7498 \
                    file://node_modules/snapdragon/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/snapdragon/node_modules/extend-shallow/package.json;md5=0f42de80e74c40652e465cce5a7e26ac \
                    file://node_modules/snapdragon/package.json;md5=aac08bb9849bebee9a80da1c3d7a8db7 \
                    file://node_modules/snapdragon-node/node_modules/define-property/package.json;md5=2afc9d66b46a8a1a06743d6004c27ecb \
                    file://node_modules/snapdragon-node/node_modules/is-accessor-descriptor/package.json;md5=e87ff36bf8e136c824e666f39140d68e \
                    file://node_modules/snapdragon-node/node_modules/is-data-descriptor/package.json;md5=6af5cb54b1bf42327c4844dd2923f0a0 \
                    file://node_modules/snapdragon-node/node_modules/is-descriptor/package.json;md5=d6a9a4950fd613bc42f5e92f16a6d52b \
                    file://node_modules/snapdragon-node/package.json;md5=0e4c7ad2db6cf7523395af399b395b51 \
                    file://node_modules/snapdragon-util/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/snapdragon-util/package.json;md5=6f3bb6a1b60d3223ec551b638c94bca0 \
                    file://node_modules/source-map/package.json;md5=7d1d048f81843bb704a2c69b3bcf3018 \
                    file://node_modules/source-map-resolve/package.json;md5=7fa43e9a62b9276ac92526ad8d65eb34 \
                    file://node_modules/source-map-url/package.json;md5=adfc3cb9d58f86534adee1eec2f6b392 \
                    file://node_modules/split-string/package.json;md5=aa98d5fde5aca0766cb64853830f0b78 \
                    file://node_modules/stack-trace/package.json;md5=075663afd2a274ef74b88c7df49dec2c \
                    file://node_modules/static-extend/node_modules/define-property/package.json;md5=c386fc0aa0f32a07a38ed040f2033f07 \
                    file://node_modules/static-extend/package.json;md5=d5e2273820801342d4944b0cc9d19dee \
                    file://node_modules/string-width/package.json;md5=97dfb4a5985832f6a8c070ca4481b96c \
                    file://node_modules/string.prototype.trimleft/package.json;md5=fe853b27207e123fca00bbaa0d38e1fc \
                    file://node_modules/string.prototype.trimright/package.json;md5=6b6ab8383bf7751e09ded5ad03c6a5e2 \
                    file://node_modules/string_decoder/package.json;md5=4a56e8c1789fe3bc13c55f8fec7e3ce2 \
                    file://node_modules/strip-ansi/package.json;md5=0b615dc471f5f434dd297c8655ed0c7f \
                    file://node_modules/strip-json-comments/package.json;md5=dcb797beecff96a1cb28676158b8a222 \
                    file://node_modules/tape/node_modules/deep-equal/package.json;md5=376ee6e759fcf5e77f694c7cdcd815e9 \
                    file://node_modules/tape/package.json;md5=c77307268e9c3ed3b71532faf9331bc3 \
                    file://node_modules/through/package.json;md5=44807c9c9205ec0de2c7d40a49e82262 \
                    file://node_modules/to-object-path/node_modules/kind-of/package.json;md5=d84b75e29c05c3a566bdfd6c768cebc8 \
                    file://node_modules/to-object-path/package.json;md5=ef9676c6bb6427cc27f317f7b62e7a84 \
                    file://node_modules/to-regex/package.json;md5=fd669d7faf4a90d37352d703bb2bc9c6 \
                    file://node_modules/to-regex-range/package.json;md5=78cf87351f668406995d7d666300de60 \
                    file://node_modules/union-value/package.json;md5=15f1461213c2ec9b21456f0965762346 \
                    file://node_modules/unset-value/node_modules/has-value/node_modules/isobject/package.json;md5=1f7c913a432a69e21c1e9734c5f85d8e \
                    file://node_modules/unset-value/node_modules/has-value/package.json;md5=92eeafb383aad6f36aedb6af1bc14b2f \
                    file://node_modules/unset-value/node_modules/has-values/package.json;md5=af83c2d5df207a2d3328235a597f264c \
                    file://node_modules/unset-value/package.json;md5=e8fb535f29316c949173b5ed2a6fa746 \
                    file://node_modules/upath/package.json;md5=1c9d5b76e0efb16015009ad94d5b718e \
                    file://node_modules/urix/package.json;md5=6efbf375a06ebd1c6339c263642345ce \
                    file://node_modules/use/package.json;md5=cb9a06a7080529dd1dd80436bc2dd5d4 \
                    file://node_modules/util-deprecate/package.json;md5=73e6c3ff1709538c921d13a75cae485d \
                    file://node_modules/utile/node_modules/async/package.json;md5=45127fb25079e1e4237fdb9a6e7c71ae \
                    file://node_modules/utile/node_modules/deep-equal/package.json;md5=dca7a07dc42041e3c2b325052bbda59f \
                    file://node_modules/utile/node_modules/ncp/package.json;md5=b8358d5a32cc56358d20d185995d57e3 \
                    file://node_modules/utile/package.json;md5=d319a35cdb23a8aa62845e8f90f21dc0 \
                    file://node_modules/window-size/package.json;md5=2bc75dd754ee49b1eaf9d069fc90042d \
                    file://node_modules/winston/node_modules/async/package.json;md5=b9af078ffbadf94f89007b64419058ef \
                    file://node_modules/winston/package.json;md5=173dd1d53109b072fcf3d8555db7e718 \
                    file://node_modules/wordwrap/package.json;md5=faea7a7078e35abb3ccef26017a56533 \
                    file://node_modules/wrap-ansi/package.json;md5=1ea40ca7800b0656e6fdf08ec2787947 \
                    file://node_modules/wrappy/package.json;md5=788804d507f3ed479ea7614fa7d3f1a5 \
                    file://node_modules/y18n/package.json;md5=5e7e8331724da47a221783bbda4a5a51 \
                    file://node_modules/yargs/package.json;md5=e53721d429cc8b88e6db0e16fb616f02"

SRC_URI = " \
    git://github.com/foreversd/forever;protocol=https \
    npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
    "

# Modify these as desired
PV = "3.0.2+git${SRCPV}"
SRCREV = "3586afef1c5de084f5fa83a6b711dbbf8ec763a8"

S = "${WORKDIR}/git"

inherit npm

RDEPENDS_${PN} = "bash"

LICENSE_${PN} = "MIT"
LICENSE_${PN}-ansi-regex = "MIT"
LICENSE_${PN}-anymatch-normalize-path = "MIT"
LICENSE_${PN}-anymatch = "ISC"
LICENSE_${PN}-arr-diff = "MIT"
LICENSE_${PN}-arr-flatten = "MIT"
LICENSE_${PN}-arr-union = "MIT"
LICENSE_${PN}-array-unique = "MIT"
LICENSE_${PN}-assign-symbols = "MIT"
LICENSE_${PN}-async = "MIT"
LICENSE_${PN}-async-each = "Unknown"
LICENSE_${PN}-atob = "Unknown"
LICENSE_${PN}-balanced-match = "Unknown"
LICENSE_${PN}-base-define-property = "MIT"
LICENSE_${PN}-base-is-accessor-descriptor = "MIT"
LICENSE_${PN}-base-is-data-descriptor = "MIT"
LICENSE_${PN}-base-is-descriptor = "MIT"
LICENSE_${PN}-base = "MIT"
LICENSE_${PN}-binary-extensions = "MIT"
LICENSE_${PN}-bindings = "MIT"
LICENSE_${PN}-brace-expansion = "MIT"
LICENSE_${PN}-braces-extend-shallow = "MIT"
LICENSE_${PN}-braces = "MIT"
LICENSE_${PN}-broadway-cliff = "MIT"
LICENSE_${PN}-broadway-eventemitter2 = "Unknown"
LICENSE_${PN}-broadway-nconf-async = "MIT"
LICENSE_${PN}-broadway-nconf = "MIT"
LICENSE_${PN}-broadway-optimist = "MIT"
LICENSE_${PN}-broadway-utile-async = "MIT"
LICENSE_${PN}-broadway-utile = "MIT"
LICENSE_${PN}-broadway-winston-async = "MIT"
LICENSE_${PN}-broadway-winston = "MIT"
LICENSE_${PN}-broadway = "MIT"
LICENSE_${PN}-cache-base = "MIT"
LICENSE_${PN}-caller = "MIT"
LICENSE_${PN}-camelcase = "MIT"
LICENSE_${PN}-chokidar = "Unknown"
LICENSE_${PN}-class-utils-define-property = "MIT"
LICENSE_${PN}-class-utils = "MIT"
LICENSE_${PN}-cliff-colors = "Unknown"
LICENSE_${PN}-cliff = "MIT"
LICENSE_${PN}-cliui = "ISC"
LICENSE_${PN}-clone = "Unknown"
LICENSE_${PN}-code-point-at = "MIT"
LICENSE_${PN}-collection-visit = "MIT"
LICENSE_${PN}-colors = "Unknown"
LICENSE_${PN}-component-emitter = "MIT"
LICENSE_${PN}-concat-map = "MIT"
LICENSE_${PN}-copy-descriptor = "MIT"
LICENSE_${PN}-core-util-is = "MIT"
LICENSE_${PN}-cycle = "Unknown"
LICENSE_${PN}-debug = "MIT"
LICENSE_${PN}-decamelize = "MIT"
LICENSE_${PN}-decode-uri-component = "MIT"
LICENSE_${PN}-deep-equal = "MIT"
LICENSE_${PN}-define-properties = "MIT"
LICENSE_${PN}-define-property-is-accessor-descriptor = "MIT"
LICENSE_${PN}-define-property-is-data-descriptor = "MIT"
LICENSE_${PN}-define-property-is-descriptor = "MIT"
LICENSE_${PN}-define-property = "MIT"
LICENSE_${PN}-defined = "MIT"
LICENSE_${PN}-director = "MIT"
LICENSE_${PN}-es-abstract = "MIT"
LICENSE_${PN}-es-to-primitive = "MIT"
LICENSE_${PN}-event-stream-optimist = "MIT"
LICENSE_${PN}-event-stream = "MIT"
LICENSE_${PN}-expand-brackets-define-property = "MIT"
LICENSE_${PN}-expand-brackets-extend-shallow = "MIT"
LICENSE_${PN}-expand-brackets = "MIT"
LICENSE_${PN}-extend-shallow-is-extendable = "MIT"
LICENSE_${PN}-extend-shallow = "MIT"
LICENSE_${PN}-extglob-define-property = "MIT"
LICENSE_${PN}-extglob-extend-shallow = "MIT"
LICENSE_${PN}-extglob-is-accessor-descriptor = "MIT"
LICENSE_${PN}-extglob-is-data-descriptor = "MIT"
LICENSE_${PN}-extglob-is-descriptor = "MIT"
LICENSE_${PN}-extglob = "MIT"
LICENSE_${PN}-eyes = "MIT"
LICENSE_${PN}-file-uri-to-path = "MIT"
LICENSE_${PN}-fill-range-extend-shallow = "MIT"
LICENSE_${PN}-fill-range = "MIT"
LICENSE_${PN}-flatiron-optimist = "MIT"
LICENSE_${PN}-flatiron = "MIT"
LICENSE_${PN}-for-in = "MIT"
LICENSE_${PN}-forever-monitor = "MIT"
LICENSE_${PN}-fragment-cache = "MIT"
LICENSE_${PN}-fsrealpath = "Unknown"
LICENSE_${PN}-fsevents = "Unknown"
LICENSE_${PN}-function-bind = "MIT"
LICENSE_${PN}-get-value = "MIT"
LICENSE_${PN}-glob-path-is-absolute = "MIT"
LICENSE_${PN}-glob = "ISC"
LICENSE_${PN}-glob-parent-is-glob = "MIT"
LICENSE_${PN}-glob-parent = "ISC"
LICENSE_${PN}-graceful-fs = "ISC"
LICENSE_${PN}-has = "MIT"
LICENSE_${PN}-has-symbols = "MIT"
LICENSE_${PN}-has-value = "MIT"
LICENSE_${PN}-has-values-kind-of = "MIT"
LICENSE_${PN}-has-values = "MIT"
LICENSE_${PN}-i = "MIT"
LICENSE_${PN}-inflight = "ISC"
LICENSE_${PN}-inherits = "ISC"
LICENSE_${PN}-ini = "ISC"
LICENSE_${PN}-invert-kv = "Unknown"
LICENSE_${PN}-is-accessor-descriptor-kind-of = "MIT"
LICENSE_${PN}-is-accessor-descriptor = "MIT"
LICENSE_${PN}-is-arguments = "MIT"
LICENSE_${PN}-is-binary-path = "MIT"
LICENSE_${PN}-is-buffer = "MIT"
LICENSE_${PN}-is-callable = "MIT"
LICENSE_${PN}-is-data-descriptor-kind-of = "MIT"
LICENSE_${PN}-is-data-descriptor = "MIT"
LICENSE_${PN}-is-date-object = "MIT"
LICENSE_${PN}-is-descriptor-kind-of = "MIT"
LICENSE_${PN}-is-descriptor = "MIT"
LICENSE_${PN}-is-extendable = "MIT"
LICENSE_${PN}-is-extglob = "MIT"
LICENSE_${PN}-is-fullwidth-code-point = "MIT"
LICENSE_${PN}-is-glob = "MIT"
LICENSE_${PN}-is-number-kind-of = "MIT"
LICENSE_${PN}-is-number = "MIT"
LICENSE_${PN}-is-plain-object = "MIT"
LICENSE_${PN}-is-regex = "MIT"
LICENSE_${PN}-is-symbol = "MIT"
LICENSE_${PN}-is-windows = "MIT"
LICENSE_${PN}-isarray = "Unknown"
LICENSE_${PN}-isobject = "MIT"
LICENSE_${PN}-isstream = "Unknown"
LICENSE_${PN}-jsonify = "Unknown"
LICENSE_${PN}-kind-of = "MIT"
LICENSE_${PN}-lazy = "Unknown"
LICENSE_${PN}-lcid = "MIT"
LICENSE_${PN}-map-cache = "MIT"
LICENSE_${PN}-map-visit = "MIT"
LICENSE_${PN}-micromatch = "MIT"
LICENSE_${PN}-minimatch = "ISC"
LICENSE_${PN}-minimist = "MIT"
LICENSE_${PN}-mixin-deep-is-extendable = "MIT"
LICENSE_${PN}-mixin-deep = "MIT"
LICENSE_${PN}-mkdirp-minimist = "MIT"
LICENSE_${PN}-mkdirp = "MIT"
LICENSE_${PN}-ms = "MIT"
LICENSE_${PN}-mute-stream = "ISC"
LICENSE_${PN}-nan = "Unknown"
LICENSE_${PN}-nanomatch = "MIT"
LICENSE_${PN}-nconf-async = "MIT"
LICENSE_${PN}-nconf = "MIT"
LICENSE_${PN}-ncp = "MIT"
LICENSE_${PN}-normalize-path = "MIT"
LICENSE_${PN}-nssocket-eventemitter2 = "Unknown"
LICENSE_${PN}-nssocket = "MIT"
LICENSE_${PN}-number-is-nan = "MIT"
LICENSE_${PN}-object-assign = "MIT"
LICENSE_${PN}-object-copy-define-property = "MIT"
LICENSE_${PN}-object-copy-kind-of = "MIT"
LICENSE_${PN}-object-copy = "MIT"
LICENSE_${PN}-object-inspect = "MIT"
LICENSE_${PN}-object-is-es-abstract = "MIT"
LICENSE_${PN}-object-is = "MIT"
LICENSE_${PN}-object-keys = "MIT"
LICENSE_${PN}-object-visit = "MIT"
LICENSE_${PN}-objectassign = "MIT"
LICENSE_${PN}-objectpick = "MIT"
LICENSE_${PN}-once = "ISC"
LICENSE_${PN}-optimist = "MIT"
LICENSE_${PN}-os-locale = "MIT"
LICENSE_${PN}-pascalcase = "MIT"
LICENSE_${PN}-path-dirname = "MIT"
LICENSE_${PN}-path-is-absolute = "MIT"
LICENSE_${PN}-pkginfo = "MIT"
LICENSE_${PN}-posix-character-classes = "MIT"
LICENSE_${PN}-prettyjson-colors = "Unknown"
LICENSE_${PN}-prettyjson-minimist = "MIT"
LICENSE_${PN}-prettyjson = "MIT"
LICENSE_${PN}-process-nextick-args = "Unknown"
LICENSE_${PN}-prompt-utile-async = "MIT"
LICENSE_${PN}-prompt-utile = "MIT"
LICENSE_${PN}-prompt = "MIT"
LICENSE_${PN}-ps-tree = "Unknown"
LICENSE_${PN}-read = "ISC"
LICENSE_${PN}-readable-stream = "Unknown"
LICENSE_${PN}-readdirp = "MIT"
LICENSE_${PN}-regex-not = "MIT"
LICENSE_${PN}-regexpprototypeflags = "MIT"
LICENSE_${PN}-remove-trailing-separator = "ISC"
LICENSE_${PN}-repeat-element = "MIT"
LICENSE_${PN}-repeat-string = "MIT"
LICENSE_${PN}-resolve-url = "MIT"
LICENSE_${PN}-resumer = "MIT"
LICENSE_${PN}-ret = "MIT"
LICENSE_${PN}-revalidator = "Unknown"
LICENSE_${PN}-rimraf = "ISC"
LICENSE_${PN}-safe-buffer = "MIT"
LICENSE_${PN}-safe-regex = "MIT"
LICENSE_${PN}-secure-keys = "Unknown"
LICENSE_${PN}-set-value-extend-shallow = "MIT"
LICENSE_${PN}-set-value = "MIT"
LICENSE_${PN}-shush = "MIT"
LICENSE_${PN}-snapdragon-define-property = "MIT"
LICENSE_${PN}-snapdragon-extend-shallow = "MIT"
LICENSE_${PN}-snapdragon = "MIT"
LICENSE_${PN}-snapdragon-node-define-property = "MIT"
LICENSE_${PN}-snapdragon-node-is-accessor-descriptor = "MIT"
LICENSE_${PN}-snapdragon-node-is-data-descriptor = "MIT"
LICENSE_${PN}-snapdragon-node-is-descriptor = "MIT"
LICENSE_${PN}-snapdragon-node = "MIT"
LICENSE_${PN}-snapdragon-util-kind-of = "MIT"
LICENSE_${PN}-snapdragon-util = "MIT"
LICENSE_${PN}-source-map = "Unknown"
LICENSE_${PN}-source-map-resolve = "MIT"
LICENSE_${PN}-source-map-url = "MIT"
LICENSE_${PN}-split-string = "MIT"
LICENSE_${PN}-stack-trace = "MIT"
LICENSE_${PN}-static-extend-define-property = "MIT"
LICENSE_${PN}-static-extend = "MIT"
LICENSE_${PN}-string-width = "MIT"
LICENSE_${PN}-stringprototypetrimleft = "MIT"
LICENSE_${PN}-stringprototypetrimright = "MIT"
LICENSE_${PN}-stringdecoder = "Unknown"
LICENSE_${PN}-strip-ansi = "MIT"
LICENSE_${PN}-strip-json-comments = "Unknown"
LICENSE_${PN}-tape-deep-equal = "Unknown"
LICENSE_${PN}-tape = "MIT"
LICENSE_${PN}-through = "MIT Unknown"
LICENSE_${PN}-to-object-path-kind-of = "MIT"
LICENSE_${PN}-to-object-path = "MIT"
LICENSE_${PN}-to-regex = "MIT"
LICENSE_${PN}-to-regex-range = "MIT"
LICENSE_${PN}-union-value = "MIT"
LICENSE_${PN}-unset-value-has-value-isobject = "MIT"
LICENSE_${PN}-unset-value-has-value = "MIT"
LICENSE_${PN}-unset-value-has-values = "MIT"
LICENSE_${PN}-unset-value = "MIT"
LICENSE_${PN}-upath = "Unknown"
LICENSE_${PN}-urix = "MIT"
LICENSE_${PN}-use = "MIT"
LICENSE_${PN}-util-deprecate = "MIT"
LICENSE_${PN}-utile-async = "MIT"
LICENSE_${PN}-utile-deep-equal = "MIT"
LICENSE_${PN}-utile-ncp = "MIT"
LICENSE_${PN}-utile = "MIT"
LICENSE_${PN}-window-size = "MIT"
LICENSE_${PN}-winston-async = "MIT"
LICENSE_${PN}-winston = "MIT"
LICENSE_${PN}-wordwrap = "MIT"
LICENSE_${PN}-wrap-ansi = "MIT"
LICENSE_${PN}-wrappy = "ISC"
LICENSE_${PN}-y18n = "ISC"
LICENSE_${PN}-yargs = "MIT"
