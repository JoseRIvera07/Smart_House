# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

SUMMARY = ""
# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# The following license files were not able to be identified and are
# represented as "Unknown" below, you will need to check them yourself:
#   node_modules/qs/LICENSE
#   node_modules/abbrev/LICENSE
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.
LICENSE = "MIT & ISC & Unknown & GPLv3"
LICENSE = "GPLv3"
LIC_FILES_CHKSUM = "file://COPYING.MIT;md5=fc9a35a08ada757cd562cebfa221c8eb \
                    file://node_modules/parseuri/LICENSE;md5=b2f87f2456eb667f9260f2af3347b45e \
                    file://node_modules/serve-static/LICENSE;md5=27b1707520b14d0bc890f4e75cd387b0 \
                    file://node_modules/base64-arraybuffer/LICENSE-MIT;md5=7e6019c14540d23cd5ed7337b94782b0 \
                    file://node_modules/fresh/LICENSE;md5=373c2cf0978b37e434394a43b4cbbdb4 \
                    file://node_modules/methods/LICENSE;md5=c16a7dd9f946172f07086576d135d9d3 \
                    file://node_modules/encodeurl/LICENSE;md5=272621efa0ff4f18a73221e49ab60654 \
                    file://node_modules/unpipe/LICENSE;md5=934ab86a8ab081ea0326add08d550739 \
                    file://node_modules/raw-body/LICENSE;md5=c970d30155ebbdb1903e6de8c0666e18 \
                    file://node_modules/setprototypeof/LICENSE;md5=4846f1626304c2c0f806a539bbc7d54a \
                    file://node_modules/engine.io/LICENSE;md5=c9f272e8d85e84d214436bc09de14478 \
                    file://node_modules/engine.io/node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/engine.io/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/engine.io/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/arraybuffer.slice/LICENCE;md5=23a30fb6334f5ebdf72ef2fbb6761dc2 \
                    file://node_modules/bytes/LICENSE;md5=013e95467eddb048f19a6f5b42820f86 \
                    file://node_modules/range-parser/LICENSE;md5=d4246fb961a4f121eef5ffca47f0b010 \
                    file://node_modules/escape-html/LICENSE;md5=f8746101546eeb9e4f6de64bb8bdf595 \
                    file://node_modules/engine.io-parser/LICENSE;md5=436a2c205caafa17c010702768e0bed0 \
                    file://node_modules/randomstring/LICENSE;md5=c5e342b2765e21bf07cf7ad6dca28075 \
                    file://node_modules/on-finished/LICENSE;md5=1b1f7f9cec194121fdf616b971df7a7b \
                    file://node_modules/finalhandler/LICENSE;md5=b506956e5cbfbe0d04f8a5c40107ec89 \
                    file://node_modules/mime/LICENSE;md5=8e8ea2ad138ce468f8570a0edbadea65 \
                    file://node_modules/safe-buffer/LICENSE;md5=badd5e91c737e7ffdf10b40c1f907761 \
                    file://node_modules/socket.io-adapter/LICENSE;md5=afbe5b2f47d5cf306759fe2d435b5ee0 \
                    file://node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/http-errors/LICENSE;md5=607209623abfcc77b9098f71a0ef52f9 \
                    file://node_modules/socket.io-parser/LICENSE;md5=afbe5b2f47d5cf306759fe2d435b5ee0 \
                    file://node_modules/socket.io-parser/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/socket.io-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/forwarded/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/qs/LICENSE;md5=d5c7c6dc45a33a0a9620ed81315672d7 \
                    file://node_modules/parseqs/LICENSE;md5=b9aac4548c7c97ac7028d5b2b111b19a \
                    file://node_modules/toidentifier/LICENSE;md5=1a261071a044d02eb6f2bb47f51a3502 \
                    file://node_modules/statuses/LICENSE;md5=36e2bc837ce69a98cc33a9e140d457e5 \
                    file://node_modules/content-disposition/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/abbrev/LICENSE;md5=e9c0b639498fbe60d17b10099aba77c0 \
                    file://node_modules/engine.io-client/LICENSE;md5=ff6b9e6830cdd3c4c2c4266dc0b91a86 \
                    file://node_modules/engine.io-client/node_modules/component-emitter/LICENSE;md5=ee4aea2d350b7bdbf93e14297dcdd8a2 \
                    file://node_modules/engine.io-client/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/engine.io-client/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/engine.io-client/node_modules/ws/LICENSE;md5=95833e8f03687308b0584a377b9e12b0 \
                    file://node_modules/media-typer/LICENSE;md5=c6e0ce1e688c5ff16db06b7259e9cd20 \
                    file://node_modules/socket.io/LICENSE;md5=852d069fbb52f1d8ed1ac32fa4b9147c \
                    file://node_modules/socket.io/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/socket.io/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/inherits/LICENSE;md5=5b2ef2247af6d355ae9d9f988092d470 \
                    file://node_modules/cookie/LICENSE;md5=bc85b43b6f963e8ab3f88e63628448ca \
                    file://node_modules/object-assign/license;md5=a12ebca0510a773644101a99a867d210 \
                    file://node_modules/send/LICENSE;md5=df2b0938eba0709b77ac937e2d552b7a \
                    file://node_modules/send/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/to-array/LICENCE;md5=8966d3100f2d871ee216d056c0ea0160 \
                    file://node_modules/iconv-lite/LICENSE;md5=f942263d98f0d75e0e0101884e86261d \
                    file://node_modules/cors/LICENSE;md5=947eb5e695dade432a500b12c510de85 \
                    file://node_modules/content-type/LICENSE;md5=f4b767f006864f81a4901347fe4efdab \
                    file://node_modules/express/LICENSE;md5=5513c00a5c36cd361da863dd9aa8875d \
                    file://node_modules/depd/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/destroy/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/blob/LICENSE;md5=cc71ab25837279e2c3667079c5d4b5f2 \
                    file://node_modules/ee-first/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/async-limiter/LICENSE;md5=4b83a79a0c223073786a52b5ece4619d \
                    file://node_modules/proxy-addr/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/vary/LICENSE;md5=13babc4f212ce635d68da544339c962b \
                    file://node_modules/mime-types/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/body-parser/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/merge-descriptors/LICENSE;md5=aaf57ba8c5c9bf256fea7e943991a81a \
                    file://node_modules/base64id/LICENSE;md5=abb57c73ecaa9ddaa151a4e424935b47 \
                    file://node_modules/parseurl/LICENSE;md5=e7842ed4f188e53e53c3e8d9c4807e89 \
                    file://node_modules/etag/LICENSE;md5=6e8686b7b13dd7ac8733645a81842c4a \
                    file://node_modules/mime-db/LICENSE;md5=c8d3a30332ecb31cfaf4c0a06da18f5c \
                    file://node_modules/array-flatten/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/yeast/LICENSE;md5=4310a14e1d911cc6e4b5a34dbcbeaddd \
                    file://node_modules/accepts/LICENSE;md5=bf1f9ad1e2e1d507aef4883fff7103de \
                    file://node_modules/ipaddr.js/LICENSE;md5=88f60a4b6e44cb849b5d907a7664c0ef \
                    file://node_modules/safer-buffer/LICENSE;md5=3baebc2a17b8f5bff04882cd0dc0f76e \
                    file://node_modules/after/LICENCE;md5=013fe0a3fb8c715466a12185bc36727b \
                    file://node_modules/node-webcam/LICENSE;md5=c872ba378fc017c5f8517dd4f18d1eb4 \
                    file://node_modules/node-webcam/src/bindings/CommandCam/COPYING;md5=d32239bcb673463ab874e80d47fae504 \
                    file://node_modules/path-to-regexp/LICENSE;md5=44088ba57cb871a58add36ce51b8de08 \
                    file://node_modules/ws/LICENSE;md5=95833e8f03687308b0584a377b9e12b0 \
                    file://node_modules/utils-merge/LICENSE;md5=1cf0906082187f374cb9a63c54eb782c \
                    file://node_modules/has-binary2/LICENSE;md5=ea88943e21663beb2f4203005de54d51 \
                    file://node_modules/socket.io-client/LICENSE;md5=b034b27f54cd5a363360fd9207438a01 \
                    file://node_modules/socket.io-client/node_modules/socket.io-parser/LICENSE;md5=afbe5b2f47d5cf306759fe2d435b5ee0 \
                    file://node_modules/socket.io-client/node_modules/socket.io-parser/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/socket.io-client/node_modules/socket.io-parser/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/socket.io-client/node_modules/ms/license.md;md5=fd56fd5f1860961dfa92d313167c37a6 \
                    file://node_modules/socket.io-client/node_modules/debug/LICENSE;md5=ddd815a475e7338b0be7a14d8ee35a99 \
                    file://node_modules/type-is/LICENSE;md5=0afd201e48c7d095454eed4ac1184e40 \
                    file://node_modules/nopt/LICENSE;md5=82703a69f6d7411dde679954c2fd9dca \
                    file://node_modules/xmlhttprequest-ssl/LICENSE;md5=cbfa18387b1df27866558353235d1cde \
                    file://node_modules/negotiator/LICENSE;md5=6417a862a5e35c17c904d9dda2cbd499 \
                    file://package.json;md5=9df53cac3b28a7b734783614e2da416b \
                    file://node_modules/abbrev/package.json;md5=09144e5559c19012a5ad2b1cb548f188 \
                    file://node_modules/accepts/package.json;md5=e6b1f36c7fc3d4a53c34db28ed1fc745 \
                    file://node_modules/after/package.json;md5=3caf383ecea554546a66a2e4d865ec9a \
                    file://node_modules/array-flatten/package.json;md5=cb1aa7f817100a03395dd0163bf6ebe9 \
                    file://node_modules/array-uniq/package.json;md5=7467c2ceef776b0e85bdd4be54fd302b \
                    file://node_modules/arraybuffer.slice/package.json;md5=2d68fad47a3cb673146397ce26974d7e \
                    file://node_modules/async-limiter/package.json;md5=1023ed343652ddb4c1948df4c789fe8a \
                    file://node_modules/backo2/package.json;md5=e7a61da3e21b35ea61a828f7939198a6 \
                    file://node_modules/base64-arraybuffer/package.json;md5=4dde471ff18e0e5683ead635fdc4aaae \
                    file://node_modules/base64id/package.json;md5=2895eacbc1a0762d80b0b1783bce4c75 \
                    file://node_modules/better-assert/package.json;md5=e9caedc3376b65e29bf02e483b6b556b \
                    file://node_modules/blob/package.json;md5=6d5409acc45751cdd04b22f41a51bb31 \
                    file://node_modules/body-parse/package.json;md5=912d5c71a2eccae385661e293f41b06d \
                    file://node_modules/body-parser/package.json;md5=d733814bad2ae132f08ab3d55c77b6a8 \
                    file://node_modules/bytes/package.json;md5=bb3cba8a8a870732b7eee0d2e4e29955 \
                    file://node_modules/callsite/package.json;md5=32235e7adb4895ecbd729d43e42ac7d2 \
                    file://node_modules/component-bind/package.json;md5=93c344398f3ccd5bb38ae0e2534c202f \
                    file://node_modules/component-emitter/package.json;md5=7d589ffe292462c7491b202e36e9eab5 \
                    file://node_modules/component-inherit/package.json;md5=50aa31ba1c2c339927b3ccad8a205650 \
                    file://node_modules/content-disposition/package.json;md5=7dd4be647ccfcb92d9943e73b26afced \
                    file://node_modules/content-type/package.json;md5=138f1013d1de872220bf2a2f2f052660 \
                    file://node_modules/convert-hex/package.json;md5=d9128ea01f30e40bca2828b793f96216 \
                    file://node_modules/convert-string/package.json;md5=14c4b05c3ef68565d039609facae80c3 \
                    file://node_modules/cookie/package.json;md5=995f6fbcc9e40fa3f539a51194665ac6 \
                    file://node_modules/cookie-signature/package.json;md5=076c53814237236a9d1aa999f33ee501 \
                    file://node_modules/cors/package.json;md5=c369e9fe8250b830e467361b042794bb \
                    file://node_modules/debug/package.json;md5=71a7656944ffe50cc27ebe02491ae49b \
                    file://node_modules/depd/package.json;md5=b6682ec09424cb14ad83a252a6748f35 \
                    file://node_modules/destroy/package.json;md5=ea66becf61cc69aece23e86ea3caf921 \
                    file://node_modules/ee-first/package.json;md5=3ed21090e07ef5dd57729a77c4291cb9 \
                    file://node_modules/encodeurl/package.json;md5=453a9bb10c91e0ec44f305b14e30ce82 \
                    file://node_modules/engine.io/node_modules/cookie/package.json;md5=f0547125fe24e399b3f2214c05157a51 \
                    file://node_modules/engine.io/node_modules/debug/package.json;md5=9e3f20bcb16871dd1be14a29001c79bd \
                    file://node_modules/engine.io/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/engine.io/package.json;md5=92e6daea88c2757c949ff1c74a092ce8 \
                    file://node_modules/engine.io-client/node_modules/component-emitter/package.json;md5=81dd6df22a2628fa27a5c4937df567f6 \
                    file://node_modules/engine.io-client/node_modules/debug/package.json;md5=9e3f20bcb16871dd1be14a29001c79bd \
                    file://node_modules/engine.io-client/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/engine.io-client/node_modules/ws/package.json;md5=6999a6821cc3d2d07b3b40c6ec557a8b \
                    file://node_modules/engine.io-client/package.json;md5=e9f4b8008d235d6e01d7b10959408248 \
                    file://node_modules/engine.io-parser/package.json;md5=4339a1d96b91bc1e02890219154ac4a6 \
                    file://node_modules/escape-html/package.json;md5=e9c758769fec9883d5ce3d30b8ee1047 \
                    file://node_modules/etag/package.json;md5=fec91cc11e50ee734c65c2d703db3884 \
                    file://node_modules/express/package.json;md5=bf6c1ca718319e619a9ebd41d5cbef6d \
                    file://node_modules/finalhandler/package.json;md5=65618bd839fed72de71aea141e19e568 \
                    file://node_modules/forwarded/package.json;md5=43c511e831e953c713743c5fc67aa990 \
                    file://node_modules/fresh/package.json;md5=193849cf18966de2814f4f6e85740069 \
                    file://node_modules/has-binary2/package.json;md5=3c15832d942d9a7f893ac4a854d0df76 \
                    file://node_modules/has-cors/package.json;md5=55651393d6d566f3981dbb4e3c02fb70 \
                    file://node_modules/http-errors/package.json;md5=18637d36709871c643fdd58b14332bf3 \
                    file://node_modules/iconv-lite/package.json;md5=a8b97f25878ddc5419a9afe173037035 \
                    file://node_modules/indexof/package.json;md5=60fa99e707a7c50ad28ca90658ddd057 \
                    file://node_modules/inherits/package.json;md5=74b2e77f5c27cdb14784f7f2512a1918 \
                    file://node_modules/ipaddr.js/package.json;md5=17bc176c8d78f76c5e70cad7ba16a598 \
                    file://node_modules/isarray/package.json;md5=e70b7c27f122e90075979692d47e1888 \
                    file://node_modules/media-typer/package.json;md5=127ce4abeb265c6eef7b45540241ca91 \
                    file://node_modules/merge-descriptors/package.json;md5=570e06d8ce0167e07a32ba70fdd56795 \
                    file://node_modules/methods/package.json;md5=8a9cbead0f83bf845207ad21534dfdfa \
                    file://node_modules/mime/package.json;md5=624ef11f91e60b224942ff81b13d10c6 \
                    file://node_modules/mime-db/package.json;md5=a2d6a0ae45675ab34540644036bae28c \
                    file://node_modules/mime-types/package.json;md5=a6bb66d39adb0d570c3f285fc161e467 \
                    file://node_modules/ms/package.json;md5=cbd55880a650b56c3d5acddbbdbee9bc \
                    file://node_modules/negotiator/package.json;md5=f532dffa79bfce9737c04201d64b5160 \
                    file://node_modules/node-webcam/package.json;md5=1f68a0a0a67f2768f268533cd59d2087 \
                    file://node_modules/nopt/package.json;md5=4e2d7d5de739353a4704cdd7c542f3a2 \
                    file://node_modules/object-assign/package.json;md5=2854c33ba575a9ebc613d1a617ece277 \
                    file://node_modules/object-component/package.json;md5=30e36da4f06afc9f8a0d4eed7fd96bbc \
                    file://node_modules/on-finished/package.json;md5=d08696acafdda765ba2fe878b287912a \
                    file://node_modules/parseqs/package.json;md5=28de552017ce502d0c0621cc3d5fe2ef \
                    file://node_modules/parseuri/package.json;md5=8f34cc2baad9e78aa4bf5f35a4aa263b \
                    file://node_modules/parseurl/package.json;md5=5b1493bd775444f0994d0b1063db1900 \
                    file://node_modules/path-to-regexp/package.json;md5=19e58964462995e183c1cd8147a9b8a1 \
                    file://node_modules/proxy-addr/package.json;md5=e99ed9f8aac6231b2559c5d17704b3e7 \
                    file://node_modules/qs/package.json;md5=8cdc396d5a17cd69a677dce0fe432492 \
                    file://node_modules/randomstring/package.json;md5=e454e44503db10f94046dd38dde3a802 \
                    file://node_modules/range-parser/package.json;md5=89b7cc42d2831a8061361ca29545f837 \
                    file://node_modules/raw-body/package.json;md5=4ff24de48d62683b79d442e1672cec63 \
                    file://node_modules/safe-buffer/package.json;md5=bd7ef6f38f0ba20882d2601bd3ecaf11 \
                    file://node_modules/safer-buffer/package.json;md5=274d956f400350c9f6cf96d22cdda227 \
                    file://node_modules/send/node_modules/ms/package.json;md5=83b5d192dde33fb41adda4ce8b9eb521 \
                    file://node_modules/send/package.json;md5=3645cd9d22c03f5bc9b3dddfe795b348 \
                    file://node_modules/serve-static/package.json;md5=d9c0bf270eb80f5b87045c69b8d6c79b \
                    file://node_modules/setprototypeof/package.json;md5=1541c2199513a8830073d21fe710bb0b \
                    file://node_modules/sha256/package.json;md5=31fc64ebabf786b070212a30fc0eb3a8 \
                    file://node_modules/socket.io/node_modules/debug/package.json;md5=9e3f20bcb16871dd1be14a29001c79bd \
                    file://node_modules/socket.io/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/socket.io/package.json;md5=55f360e00ad9f5350ec66a511f6c54c6 \
                    file://node_modules/socket.io-adapter/package.json;md5=8f5fe58cc737425969f3150e12a9d9e3 \
                    file://node_modules/socket.io-client/node_modules/debug/package.json;md5=9e3f20bcb16871dd1be14a29001c79bd \
                    file://node_modules/socket.io-client/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/socket.io-client/node_modules/socket.io-parser/node_modules/debug/package.json;md5=cd0b3a0d33bee20af1c9452cccf99e17 \
                    file://node_modules/socket.io-client/node_modules/socket.io-parser/node_modules/ms/package.json;md5=cbd55880a650b56c3d5acddbbdbee9bc \
                    file://node_modules/socket.io-client/node_modules/socket.io-parser/package.json;md5=857495b4bcf2f01fd58a04215eddf155 \
                    file://node_modules/socket.io-client/package.json;md5=ba9fa45e0b04f3dd29cf90654568da5b \
                    file://node_modules/socket.io-parser/node_modules/debug/package.json;md5=9e3f20bcb16871dd1be14a29001c79bd \
                    file://node_modules/socket.io-parser/node_modules/ms/package.json;md5=b3ea7267a23f72028e774742792b114a \
                    file://node_modules/socket.io-parser/package.json;md5=40ac5f126ff82e10f21156ee736d6004 \
                    file://node_modules/statuses/package.json;md5=ce09e65d18aa8425eac89e41fde1837a \
                    file://node_modules/to-array/package.json;md5=9ceab7187fa99b7f01e5e74ec2b9543c \
                    file://node_modules/toidentifier/package.json;md5=2ecc7acf5b134a92fbc0b0999a02f84d \
                    file://node_modules/type-is/package.json;md5=ffa244d8a6f745a081a0cdde026879c9 \
                    file://node_modules/unpipe/package.json;md5=f8318a554ed98c6a030942e9c14aaac8 \
                    file://node_modules/utils-merge/package.json;md5=0230ade39b9c19f5fcc29ed02dff4afe \
                    file://node_modules/vary/package.json;md5=3577fc17c1b964af7cfe2c17c73f84f3 \
                    file://node_modules/ws/package.json;md5=b527b059ef83db0bca2dafe928465a98 \
                    file://node_modules/xmlhttprequest-ssl/package.json;md5=c84c8978216b3f15d40875a9d68b624a \
                    file://node_modules/yeast/package.json;md5=a3683df9e0d262b372f3863a3af9e7d0"

# No information for SRC_URI yet (only an external source tree was specified)
SRC_URI = " \
    npmsw://${THISDIR}/${BPN}/npm-shrinkwrap.json \
    "

inherit npm

RDEPENDS_${PN} = "bash"


LICENSE_${PN} = "MIT"
LICENSE_${PN}-abbrev = "Unknown"
LICENSE_${PN}-accepts = "MIT"
LICENSE_${PN}-after = "MIT"
LICENSE_${PN}-array-flatten = "MIT"
LICENSE_${PN}-array-uniq = "Unknown"
LICENSE_${PN}-arraybufferslice = "MIT"
LICENSE_${PN}-async-limiter = "MIT"
LICENSE_${PN}-backo2 = "Unknown"
LICENSE_${PN}-base64-arraybuffer = "MIT"
LICENSE_${PN}-base64id = "MIT"
LICENSE_${PN}-better-assert = "Unknown"
LICENSE_${PN}-blob = "MIT"
LICENSE_${PN}-body-parse = "Unknown"
LICENSE_${PN}-body-parser = "MIT"
LICENSE_${PN}-bytes = "MIT"
LICENSE_${PN}-callsite = "Unknown"
LICENSE_${PN}-component-bind = "Unknown"
LICENSE_${PN}-component-emitter = "MIT"
LICENSE_${PN}-component-inherit = "Unknown"
LICENSE_${PN}-content-disposition = "MIT"
LICENSE_${PN}-content-type = "MIT"
LICENSE_${PN}-convert-hex = "Unknown"
LICENSE_${PN}-convert-string = "Unknown"
LICENSE_${PN}-cookie = "MIT"
LICENSE_${PN}-cookie-signature = "Unknown"
LICENSE_${PN}-cors = "MIT"
LICENSE_${PN}-debug = "MIT"
LICENSE_${PN}-depd = "MIT"
LICENSE_${PN}-destroy = "MIT"
LICENSE_${PN}-ee-first = "MIT"
LICENSE_${PN}-encodeurl = "MIT"
LICENSE_${PN}-engineio-cookie = "MIT"
LICENSE_${PN}-engineio-debug = "MIT"
LICENSE_${PN}-engineio-ms = "MIT"
LICENSE_${PN}-engineio = "MIT"
LICENSE_${PN}-engineio-client-component-emitter = "MIT"
LICENSE_${PN}-engineio-client-debug = "MIT"
LICENSE_${PN}-engineio-client-ms = "MIT"
LICENSE_${PN}-engineio-client-ws = "MIT"
LICENSE_${PN}-engineio-client = "MIT"
LICENSE_${PN}-engineio-parser = "MIT"
LICENSE_${PN}-escape-html = "MIT"
LICENSE_${PN}-etag = "MIT"
LICENSE_${PN}-express = "MIT"
LICENSE_${PN}-finalhandler = "MIT"
LICENSE_${PN}-forwarded = "MIT"
LICENSE_${PN}-fresh = "MIT"
LICENSE_${PN}-has-binary2 = "MIT"
LICENSE_${PN}-has-cors = "Unknown"
LICENSE_${PN}-http-errors = "MIT"
LICENSE_${PN}-iconv-lite = "MIT"
LICENSE_${PN}-indexof = "Unknown"
LICENSE_${PN}-inherits = "ISC"
LICENSE_${PN}-ipaddrjs = "MIT"
LICENSE_${PN}-isarray = "Unknown"
LICENSE_${PN}-media-typer = "MIT"
LICENSE_${PN}-merge-descriptors = "MIT"
LICENSE_${PN}-methods = "MIT"
LICENSE_${PN}-mime = "MIT"
LICENSE_${PN}-mime-db = "MIT"
LICENSE_${PN}-mime-types = "MIT"
LICENSE_${PN}-ms = "MIT"
LICENSE_${PN}-negotiator = "MIT"
LICENSE_${PN}-node-webcam = "MIT GPLv3"
LICENSE_${PN}-nopt = "ISC"
LICENSE_${PN}-object-assign = "MIT"
LICENSE_${PN}-object-component = "Unknown"
LICENSE_${PN}-on-finished = "MIT"
LICENSE_${PN}-parseqs = "MIT"
LICENSE_${PN}-parseuri = "MIT"
LICENSE_${PN}-parseurl = "MIT"
LICENSE_${PN}-path-to-regexp = "MIT"
LICENSE_${PN}-proxy-addr = "MIT"
LICENSE_${PN}-qs = "Unknown"
LICENSE_${PN}-randomstring = "MIT"
LICENSE_${PN}-range-parser = "MIT"
LICENSE_${PN}-raw-body = "MIT"
LICENSE_${PN}-safe-buffer = "MIT"
LICENSE_${PN}-safer-buffer = "MIT"
LICENSE_${PN}-send-ms = "MIT"
LICENSE_${PN}-send = "MIT"
LICENSE_${PN}-serve-static = "MIT"
LICENSE_${PN}-setprototypeof = "ISC"
LICENSE_${PN}-sha256 = "Unknown"
LICENSE_${PN}-socketio-debug = "MIT"
LICENSE_${PN}-socketio-ms = "MIT"
LICENSE_${PN}-socketio = "MIT"
LICENSE_${PN}-socketio-adapter = "MIT"
LICENSE_${PN}-socketio-client-debug = "MIT"
LICENSE_${PN}-socketio-client-ms = "MIT"
LICENSE_${PN}-socketio-client-socketio-parser-debug = "MIT"
LICENSE_${PN}-socketio-client-socketio-parser-ms = "MIT"
LICENSE_${PN}-socketio-client-socketio-parser = "MIT"
LICENSE_${PN}-socketio-client = "MIT"
LICENSE_${PN}-socketio-parser-debug = "MIT"
LICENSE_${PN}-socketio-parser-ms = "MIT"
LICENSE_${PN}-socketio-parser = "MIT"
LICENSE_${PN}-statuses = "MIT"
LICENSE_${PN}-to-array = "MIT"
LICENSE_${PN}-toidentifier = "MIT"
LICENSE_${PN}-type-is = "MIT"
LICENSE_${PN}-unpipe = "MIT"
LICENSE_${PN}-utils-merge = "MIT"
LICENSE_${PN}-vary = "MIT"
LICENSE_${PN}-ws = "MIT"
LICENSE_${PN}-xmlhttprequest-ssl = "MIT"
LICENSE_${PN}-yeast = "MIT"
